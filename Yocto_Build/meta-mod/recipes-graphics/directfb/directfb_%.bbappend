BBCLASSEXTEND = "native nativesdk"
EXTRA_OECONF += "--disable-multi"