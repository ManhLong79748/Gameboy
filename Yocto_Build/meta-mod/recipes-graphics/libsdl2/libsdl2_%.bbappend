DEPENDS += "directfb"
EXTRA_OECONF += "--disable-video-x11 --disable-video-kmsdrm --disable-alsa"